Commit message: autogenerated urdf file for panda robot

File: panda.urdf (robot description, URDF)
Before this commit: robot panda, 24 links, 23 joints
Joints:
- joint panda_link8_to_extra_link: origin xyz=0 0 0.134 rpy=0 0 -0.7854 -> xyz=0 0 0.1034 rpy=0 0 -0.785398
